# Keil uVision project iRobot.uvprojx, settings and files
target iRobot (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iRobot +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: .\Lib\inc;.\User;.\Control;.\Core;.\Driver\ADC;.\Driver\DMP;.\Driver\ENCODER;.\Driver\EXTI;.\Driver\IIC;.\Driver\KEY;.\Driver\LED;.\Driver\MOTOR;.\Driver\MPU6050;.\Driver\OLED;.\Driver\STMFLASH;.\Driver\USART2;.\Driver\USART3;.\System\delay;.\System\sys;.\System\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group Control
    ./Control/: control.c show.c
  group Driver
    ./Driver/ADC/: adc.c
    ./Driver/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Driver/ENCODER/: encoder.c
    ./Driver/EXTI/: exti.c
    ./Driver/IIC/: IOI2C.c
    ./Driver/KEY/: key.c
    ./Driver/LED/: LED.C
    ./Driver/MOTOR/: motor.c
    ./Driver/MPU6050/: MPU6050.c
    ./Driver/OLED/: oled.c
    ./Driver/STMFLASH/: stmflash.c
    ./Driver/USART2/: usart2.c
    ./Driver/USART3/: usart3.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
